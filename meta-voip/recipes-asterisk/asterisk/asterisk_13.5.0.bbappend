# FIX: | menuselect.c:35:27: fatal error: libxml/parser.h: No such file or directory
DEPENDS += "libxml2"

