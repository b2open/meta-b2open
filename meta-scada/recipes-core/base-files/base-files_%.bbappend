# Only with recipe servlet2.5 (tomcat6)
#do_install_append_pn-servlet2.5 () {
#}
