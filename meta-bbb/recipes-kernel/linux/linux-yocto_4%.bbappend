FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " \
  file://enable_dri_tilcdc_and_kms_swrast_dri.cfg \
  "

