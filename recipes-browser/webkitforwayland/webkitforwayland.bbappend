EXTRA_OECMAKE = " \
                 -DPORT=WPE \
                 -DCMAKE_BUILD_TYPE=Release \
                 -DCMAKE_COLOR_MAKEFILE=OFF -DBUILD_SHARED_LIBS=ON \
                 -DUSE_WPE_BACKEND_DRM=OFF \
                 "
